Commit message: add rviz launch files

File: urdf/umnitsa_nano.urdf (robot description, URDF)
Before this commit: robot myfirst, 6 links, 5 joints
Links:
- removed link laser_base
- added link laser
Joints:
- joint base_to_laser: child laser_base -> laser
